# Keil uVision project headController9.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: headController9 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\headController9_MDR
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c hardware.c str.c sequins.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.0.2i, Drivers:ADC 2.0.2i, Drivers:EEPROM 2.0.2i, Drivers:I2C 2.0.2i, Drivers:PORT 2.0.2i, Drivers:POWER 2.0.2i, Drivers:RST_CLK 2.0.2i, Drivers:TIMER 2.0.2i, Drivers:UART 2.0.2i
